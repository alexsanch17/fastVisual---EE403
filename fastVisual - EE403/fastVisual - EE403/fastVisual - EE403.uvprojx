# Keil uVision project fastVisual - EE403.uvprojx, settings and files
target Lab6 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC54608J512ET180:M4 NXP
  pack: Keil.LPC54000_DFP.2.2.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: lab6.out +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_LPC54608, CPU_LPC54608J512ET180=1,ARM_MATH_CM4,__FPU_PRESENT
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: .\SRC\eGFX;.\SRC\eGFX\Drivers;.\SRC\eGFX\Fonts;.\SRC\Board;.\SRC\System\CMSIS\Include;.\SRC\System\utilities;.\SRC\Drivers;.\SRC\System;.\SRC\eGFX\Fonts\OCR_A_Extended__20px__Bold__SingleBitPerPixelGridFit_1BPP;.\SRC\Audio;.\SRC\eGFX\Sprites;.\SRC\eGFX\Fonts\Consolas__26px__Regular__AntiAliasGridFit_1BPP;.\SRC\eGFX\Fonts\Magneto__26px__Regular__AntiAliasGridFit_16BPP_565;.\SRC\eGFX\Fonts\Arial__23px__Regular__SystemDefault_1BPP
  asm define: CPU_LPC54114J256_M4, DEBUG,__CC_ARM,KEIL
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20010000 size 0x10000
  scatter file: .\LPC54608J512_flash.scf
  link misc: ./LIB/keil_lib_power.lib 
../CMSIS-DSP/LIB/CMSIS_DSP_4_5_O3.lib
--remove 
--show_parent_lib --show_full_path
  group System
    ./SRC/System/: fsl_device_registers.h LPC54608.h LPC54608_features.h startup_LPC54608.s system_LPC54608.c system_LPC54608.h SDRAM.C SDRAM.h fsl_ft5406.c fsl_ft5406.h
    ./SRC/System/utilities/: fsl_debug_console.c fsl_debug_console.h
  group drivers
    ./SRC/Drivers/: fsl_adc.c fsl_adc.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_crc.c fsl_crc.h fsl_ctimer.c fsl_ctimer.h fsl_dma.c fsl_dma.h fsl_dmic.c fsl_dmic.h fsl_dmic_dma.c fsl_dmic_dma.h fsl_eeprom.c fsl_eeprom.h fsl_emc.c fsl_emc.h fsl_enet.c fsl_enet.h fsl_flashiap.c fsl_flashiap.h fsl_flexcomm.c fsl_flexcomm.h fsl_fmc.c fsl_fmc.h fsl_fmeas.c fsl_fmeas.h fsl_gint.c fsl_gint.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_i2c_dma.c fsl_i2c_dma.h fsl_i2s.c fsl_i2s.h fsl_i2s_dma.c fsl_i2s_dma.h fsl_inputmux.c fsl_inputmux.h fsl_inputmux_connections.h fsl_iocon.h fsl_lcdc.c fsl_lcdc.h fsl_mcan.c fsl_mcan.h fsl_mrt.c fsl_mrt.h fsl_otp.h fsl_pint.c fsl_pint.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_rit.c fsl_rit.h fsl_rng.h fsl_rtc.c fsl_rtc.h fsl_sctimer.c fsl_sctimer.h fsl_sdif.c fsl_sdif.h fsl_spi.c fsl_spi.h fsl_spi_dma.c fsl_spi_dma.h fsl_spifi.c fsl_spifi.h fsl_spifi_dma.c fsl_spifi_dma.h fsl_usart.c fsl_usart.h fsl_usart_dma.c fsl_usart_dma.h fsl_utick.c fsl_utick.h fsl_wwdt.c fsl_wwdt.h
  group main
    ./SRC/: main.c
  group board
    ./SRC/Board/: board.c clock_config.c pin_mux.c board.h clock_config.h pin_mux.h
  group eGFX
    ./SRC/eGFX/: eGFX.c eGFX.h eGFX_DataTypes.h eGFX_Driver.h
    ./SRC/eGFX/Drivers/: eGFX_Driver_LPCXPresso_54608.c
    ./SRC/eGFX/Fonts/: FONT_5_7_1BPP.c FONT_3_5_1BPP.c
    ./SRC/eGFX/Fonts/OCR_A_Extended__20px__Bold__SingleBitPerPixelGridFit_1BPP/: OCR_A_Extended__20px__Bold__SingleBitPerPixelGridFit_1BPP.c OCR_A_Extended__20px__Bold__SingleBitPerPixelGridFit_1BPP.h
    ./SRC/eGFX/Sprites/: Sprites_16BPP_565.c
    ./SRC/eGFX/Fonts/Consolas__26px__Regular__AntiAliasGridFit_1BPP/: Consolas__26px__Regular__AntiAliasGridFit_1BPP.c Consolas__26px__Regular__AntiAliasGridFit_1BPP.h
    ./SRC/eGFX/Fonts/Magneto__26px__Regular__AntiAliasGridFit_16BPP_565/: Magneto__26px__Regular__AntiAliasGridFit_16BPP_565.h Magneto__26px__Regular__AntiAliasGridFit_16BPP_565.c
  group Audio
    ./SRC/Audio/: fsl_wm8904.c fsl_wm8904.h Audio.c Audio.h
